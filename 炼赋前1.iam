# Autodesk Inventor assembly: 조립품1
## iProperties
Created: 2015-06
Part Number: 조립품1
Document SubType Name: Assembly
Designer: elite
Author: elite
